# Keil uVision project MDIO_Intelecon.uvprojx, settings and files
target STM32F042C6 (ARM-ADS)
  device: STM32F042C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LiftPost +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F042, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Include;..\User\Modbus;..\User\Modbus2;..\User\W5500;..\User\Devices;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group User
    ../User/: main.c stm32f0xx_it.c gpio.c can.c crc.c
  group Modbus
    ../User/Modbus/: RS485_modbus.c
  group W5500
    ../User/W5500/: W5500_SPI.c W5500_Utils.c
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_can.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c stm32f0xx_misc.c stm32f0xx_usart.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group Readme
    ../User/: Readme.txt
  group Devices
    ../User/Devices/: devices.c BVK.c Joystick.c BPS.c BVK_SHEEM.c
